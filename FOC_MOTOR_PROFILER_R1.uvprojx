# Keil uVision project FOC_MOTOR_PROFILER_R1.uvprojx, settings and files
target FOC_MOTOR_PROFILER_R1 (6220000::V6.22::ARMCLANG)
  device: STM32F031C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: FOC_MOTOR_PROFILER_R1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM0,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F031x6
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../MCSDK_v6.3.2-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v6.3.2-Full/MotorControl/MCSDK/MCLib/F0xx/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f031x6.s
  group Application/User
    ../Src/: main.c motorcontrol.c pwm_common.c mc_api.c mc_config.c mc_config_common.c mcp_config.c mc_tasks.c mc_tasks_sixstep.c regular_conversion_manager.c mc_math.c mc_interface.c stm32_mc_common_it.c stm32f0xx_mc_it.c mc_parameters.c register_interface.c mcp.c usart_aspep_driver.c mc_configuration_registers.c aspep.c mc_app_hooks.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_adc.c stm32f0xx_ll_dma.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c stm32f0xx_ll_exti.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Middlewares/MotorControl
    ../MCSDK_v6.3.2-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c ntc_temperature_sensor.c pid_regulator.c pwmc_sixstep.c r_divider_bus_voltage_sensor.c revup_ctrl_sixstep.c speed_pos_fdbk.c speed_ctrl.c virtual_speed_sensor.c
    ../MCSDK_v6.3.2-Full/MotorControl/MCSDK/MCLib/F0xx/Src/: f0xx_bemf_ADC_fdbk.c
software components: CMSIS:CORE 6.1.0
